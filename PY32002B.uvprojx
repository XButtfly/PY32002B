# Keil uVision project PY32002B.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.9
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32002B
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F002Bx5, USE_FULL_LL_DRIVER, HSI_VALUE=24000000U
  c include: .\Inc;..\PY32F002B\Drivers\CMSIS\Include;..\PY32F002B\Drivers\CMSIS\Device\PY32F0xx\Include;..\PY32F002B\Drivers\PY32F002B_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Startup
    $$Device:PY32F002Bx5$Device/Source/ARM/: startup_py32f002bx5.s
  group User
    ./Src/: main.c py32f002b_it.c system_py32f002b.c syscalls.c ws2812.c sd1516.c
  group Drivers
    ../PY32F002B/Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_flash.c py32f002b_hal_cortex.c py32f002b_ll_utils.c py32f002b_ll_usart.c py32f002b_ll_rcc.c py32f002b_ll_exti.c py32f002b_ll_adc.c
